# Keil uVision project Three dimensional compass.uvprojx, settings and files
target Three dimensional compass (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Three dimensional compass +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,ARM_MATH_CM3,DEBUG_ENABLE_SEMIHOST,QST_USE_SW_I2C
  c include: .\Chip\inc;.\Chip\CMSIS;.\User;.\User\AHRS;.\User\Driver\Inc;.\User\Controler\Inc;.\Chip\CMSIS\startup;.\Chip\DSP_Lib\CommonTables;.\Chip\DSP_Lib;.\User\Modules\Inc;.\Chip\USB;.\Chip\USB\Config;.\Chip\USB\Core;.\User\Controler\NCQ_Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Chip
    ./Chip/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ./User/: main.c stm32f10x_it.c angle_calculation.c calibration.c
  group Driver
    ./User/Driver/Src/: SYSTEM.c qst_sw_i2c.c qmc6308.c QMAX981.c bsp_key.c stmflash.c
  group CMSIS
    ./Chip/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./Chip/CMSIS/startup/arm/: startup_stm32f10x_hd.s
    ./Chip/CMSIS/startup/: core_cm3.c
